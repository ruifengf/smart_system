# Keil uVision project smartsystem.uvprojx, settings and files
target smart_system (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smartsystem
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\FWLIB;.\FWLIB\inc;C:\Keil_v5\ARM\Pack;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\1.0.8\Device\Include;.\Hardware;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\1.0.8\Device\StdPeriph_Driver\templates
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group CORE
    ./CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx_conf.h RTE_Components.h
  group FWLIB
    ./FWLIB/src/: stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_gpio.c misc.c stm32f4xx_rcc.c stm32f4xx_exti.c
  group Hardware
    ./Hardware/: led.c blue_tooth.c timer.c usb_ttl.c button.c delay.c exti.c tim.c usart.c ultrasound.c
software components: Device:StdPeriph Drivers:SYSCFG 1.3.0
